Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL+_INT-EN.ifc
Time: 2025-08-05T18:29:21+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2035683_1 | SINK
OutPort_2035683_2 | SOURCE

# IfcValve: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL_INT-EN:SpiroPure Home XL+, M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL_INT-EN:SpiroPure Home XL+:2035683
In: F00
Type - Material: Color RGB 200-200-200, Color RGB 200-000-000, Color RGB 168-128-048, Color RGB 055-055-055, Color RGB 229-190-001, Color RGB 150-150-150
Type - Other - Category: Pipe Accessories; b: 301 mm; b1: 298 mm; Family Name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL_INT-EN; h: 543 mm; h1: 70 mm; Home Basic+: yes; Tank Radius: 106 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 139 mm; Height: 613 mm; Use Nominal Diameter: yes; Water Inlet Connection Diameter: 19 mm; Water Outlet Connection Diameter: 19 mm; Width: 599 mm
Type - Identity Data - Article Description: Fixed replenishment units - cap. 225 ltr - Fillcombi; Article Type: SpiroPure Home XL+; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: ©Trimble Europe BV; Custom: no; Description: Fixed replenishment units - cap. 225 ltr - Fillcombi; EMCS Version: 5.0; ETIM Article Class: EC011325; Family Version: 24.10; GLN: 8717811000007; GTIN: 8717811064528; Manufacturer: Spirotech; Manufacturer Art. No.: G76.352; Manufacturer URL: https://www.spirotech.com/8717811064528; MEPcontent Class: FILTER; Model: SpiroPure Home XL+; OmniClass Number: 23.75.50.11.14; OmniClass Title: Feedwater Equipment; Product Line: Spirotech; Revit Version: 2023; Type Name: SpiroPure Home XL+; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass: Color RGB 168-128-048; Grey: Color RGB 150-150-150; Red: Color RGB 200-000-000; White: Color RGB 200-200-200; Yellow: Color RGB 229-190-001
Type - Mechanical - Max Filling Capacity: 0.225 m3; Resin Volume: 0.0017 m3; Weight: 5 kg; Working Pressure: 1.5 to 8 bar; Working Temperature: 5 to 40°C
Type - Mechanical - Flow - Max Flow: 0.0000666667 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: SpiroPure Home XL+; sets with these values: 2
Other - Back Clearance Safe: 0 mm; Bottom Clearance Safe: 25 mm; Family: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL_INT-EN; Family and Type: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Home XL_INT-EN: SpiroPure Home XL+; Front Clearance Safe: 0 mm; Left Clearance Safe: 0 mm; Right Clearance Safe: 0 mm; Top Clearance Safe: 160 mm; Type: SpiroPure Home XL+; Type Id: 2035667
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.856216 m2; Maximum Size: 19 mm; Minimum Size: 19 mm; Volume: 0.00693637 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa; Water Inlet Connection Flow: 0 m3/s; Water Outlet Connection Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Bottom Clearance: 25 mm; Front Clearance: 0 mm; Left Clearance: 0 mm; Right Clearance: 0 mm; Show Service Area: no; Top Clearance: 160 mm
Insulation - Insulation Thickness: 0 mm
